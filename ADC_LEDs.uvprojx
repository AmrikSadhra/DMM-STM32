# Keil uVision project ADC_LEDs.uvprojx, settings and files
target STM32F407 FLASH (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F407VG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ADC_LEDs
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,STM32F4XX,KEIL_IDE,HSE_VALUE=8000000,PLL_M=8,PLL_N=336,PLL_P=2,PLL_Q=7
  c include: .\DMM;.\Libraries\CMSIS\Include;.\Libraries\CMSIS\STM32F4xx\Include;.\Libraries\STM32F4xx_StdPeriph_Driver\inc;.\Utilities\STM32F407-Discovery
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group HAL
    ./Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_gpio.c misc.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_exti.c stm32f4xx_syscfg.c stm32f4xx_adc.c stm32f4xx_dac.c stm32f4xx_dma.c
  group Source Files
    ./: adc.c dac.c dmm.c lcd_buffer.c lcd_driver.c packet.c queue.c serial.c switches.c utils.c
software components: CMSIS:CORE 5.0.0, Device:Startup 2.6.0
